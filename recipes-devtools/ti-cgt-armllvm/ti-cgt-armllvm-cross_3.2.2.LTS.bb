require ti-cgt-armllvm-cross.inc

TOOLCHAIN_BIN = "ti_cgt_armllvm_3.2.2.LTS_linux-x64_installer.bin"

SRC_URI[sha256sum] = "2864bb1013ec60b1290f92ff723a4fc222653db1278c08ad81af6063f698dec9"
