require sysconfig-cross.inc

SYSCONFIG_BIN = "sysconfig-1.20.0_3587-setup.run"

SRC_URI[sha256sum] = "983a2aa6677d6dadc14942a8f3e3b1fbe9c3a36269fd46ea259dfa499b97c373"
