FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PACKAGECONFIG:remove = "networkd"
